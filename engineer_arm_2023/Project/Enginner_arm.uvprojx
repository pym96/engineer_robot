# Keil uVision project Enginner_arm.uvprojx, settings and files
target Enginner_arm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Enginner_arm_2023
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=1
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\App\Inc;..\Core;..\Device\Inc;..\MiddleWare\FreeRTOS\portable\RVDS\ARM_CM4F;..\MiddleWare\FreeRTOS\include;..\ModuleDrivers\Inc;..\Platform\Inc;..\Protocol\Inc;..\STM32F4xx_FWLib\inc;..\Task\Inc;..\Algorithm\inc
  asm define: __FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: app_motor.cpp app_led.cpp app_power_ctrl.cpp app_usart7.cpp app_gomotor.cpp
  group Task
    ../Task/: start_task.cpp RTOSsystem_task.cpp Kinematics_Task.cpp Get_aim_task.cpp guard_task.cpp Chassis_Task.cpp Message_Task.cpp Correspondence_Task.cpp
  group Device
    ../App/: main.cpp
    ../Device/: dev_system.cpp dev_can.cpp dev_serial.cpp
  group MiddleWare
    ../MiddleWare/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../MiddleWare/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../MiddleWare/FreeRTOS/portable/MemMang/: heap_4.c
    ../MiddleWare/DSP/: arm_cortexM4lf_math.lib
  group Platform
    ../Platform/: platform_io.c platform_exti.c platform_systick.c platform_pwm.c platform_timer.c
  group ModuleDrivers
    ../ModuleDrivers/: drivers_buffer.cpp drivers_dma.cpp drivers_led.cpp drivers_serial.cpp drivers_remote.cpp drivers_can.cpp drivers_state_machines.cpp
  group Algorithm
    ../Algorithm/: algorithm_pid.cpp algorithm_user_lib.cpp lqr.cpp feedforward.cpp Adaptive_exercise.cpp
  group STM32F4xx_FWLib
    ../STM32F4xx_FWLib/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_spi.c
  group Core
    ../Core/: stm32f4xx_it.c system_stm32f4xx.c
    ./: startup_stm32f427xx.s
  group protocl
    ../Protocol/: protocol_crc.cpp protocol_dbus.cpp
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
